#Allow this recipe to be used in for creation of native SDKs.
BBCLASSEXTEND = "native nativesdk"
