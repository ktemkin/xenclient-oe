PR .= ".1"

# TODO: Not necessary once using new meta-selinux repo
inherit pythonnative
