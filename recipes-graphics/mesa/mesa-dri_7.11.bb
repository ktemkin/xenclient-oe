include mesa-common.inc
include mesa-${PV}.inc
include mesa-dri.inc
PR = "${INC_PR}.1"
<<<<<<< HEAD

inherit autotools-brokensep pkgconfig
=======
>>>>>>> Massive commit pulling old recipes and setting preferred versions so the uivm image will
